## config/boards/shields/mochi40_ec11_oled/Kconfig
```kconfig
config SHIELD_MOCHI40_EC11_OLED
    def_bool y
Add Mochi40 EC11 OLED shield config and keymap
```
